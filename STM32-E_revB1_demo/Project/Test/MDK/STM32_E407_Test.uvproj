# Keil uVision project STM32_E407_Test.uvproj, settings and files
target STM_E407_Test (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32_E407_Test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,ARMCMX,OLIMEX_STM_E407,HSE_VALUE=12000000,__CORE__=7
  c include: ..\..\Test;..\..\..\board;..\..\..\modules;..\Ethernet\app;..\Ethernet\uip;..\Ethernet\uip\httpd;..\USB\app;..\..\..\..\stm32library\STM32_USB_Device_Library\Core\inc;..\..\..\..\stm32library\STM32_USB_OTG_Driver\inc;..\..\..\..\stm32library\STM32_USB_Device_Library\Class\hid\inc;..\..\..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\STM32Libraries\armcmx;..\..\..\..\STM32Libraries\STM32F4x7_ETH_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user_main
    ../: main.c includes.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../../../../STM32Libraries/armcmx/utility/: system_stm32f4xx.c
  group board
    ../../../board/: arm_comm.h iar_stm32f217ze_sk.c iar_stm32f217ze_sk.h
    ../../../../STM32Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../../../../STM32Libraries/STM32F4x7_ETH_Driver/inc/: stm32f4x7_eth.h stm32f4x7_eth_conf_template.h
  group comm
    ../../../modules/: disk.h i2c1_drv.c i2c1_drv.h sd_card_mode old.c sd_card_mode.c sd_card_mode.h Sin_Table.c Sin_Table.h
  group Ethernet
    ../Ethernet/app/: clock-arch.c ethernet.c clock-arch.h ethernet.h tapdev.h uip-conf.h uipopt.h
