# Keil uVision project stm32f4xx_GPIO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4xx_GPIO
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F4_DISCOVERY
  c include: ..\..\..\armcmx;..\..\..\armcmxutil;..\..\..\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: main.cpp
    ../../../armcmxutil/: stm32f4xx_conf.h stm32f4xx_it.h stm32f4xx_it.c
    ../../../armcmxutil/CMSIS/: system_stm32f4xx.c
    ../../../armcmxutil/board/: stm32_open407vc.h
  group stdperiph
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armcmx
    ../../../armcmx/: delay.c armcmx.c gpio.c i2c.c usart.c
