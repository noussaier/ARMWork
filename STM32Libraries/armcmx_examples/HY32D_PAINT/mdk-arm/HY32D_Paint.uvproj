# Keil uVision project HY32D_Paint.uvproj, settings and files
target HY32D_Paint (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: HY32D_Paint
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,OPEN407VC,HSE_VALUE=8000000,STDSERIAL=3
  c include: ..\;..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\armcmx;..\..\..\armcmx\library\GLCD\SSD1289;..\..\..\armcmx\library\TouchScreenController;..\..\..\armcmxlib\GLCD\fonts;..\..\..\armcmx\utility\board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main Group
    ./: startup_stm32f4xx.s
    ../: stm32f4xx_conf.h main.cpp
    ../../../armcmx/utility/: stm32f4xx_it.c
    ../../../armcmx/utility/CMSIS/: system_stm32f4xx.c
  group stdperiph_driver
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group armcmx
    ../../../armcmx/: armcmx.c delay.c gpio.c spi.c usart.c
  group periphlib
    ../../../armcmx/library/GLCD/SSD1289/: SSD1289.cpp AsciiLib.c
    ../../../armcmx/library/TouchScreenController/: ads7864.cpp
