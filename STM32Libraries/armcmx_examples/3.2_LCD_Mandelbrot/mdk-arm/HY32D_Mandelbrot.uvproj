# Keil uVision project HY32D_Mandelbrot.uvproj, settings and files
target Mandelbrot (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: HY32D_Mandelbrot
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4_DISCOVERY,HSE_VALUE=8000000
  c include: ..\..\3.2_LCD_Mandelbrot;..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\armcmx;..\..\..\armcmx\library\GLCD\SSD1289
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
    ../: Julija.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h main.cpp
  group stdperiph
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c
  group armcmx
    ../../../armcmx/: armcmx.c delay.c gpio.c usart.c
  group cmsis
    ../../../armcmx/utility/CMSIS/: system_stm32f4xx.c
  group GLCD
    ../../../armcmx/library/GLCD/SSD1289/: SSD1289.cpp SSD1289.h AsciiLib.h AsciiLib.c
