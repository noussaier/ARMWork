# Keil uVision project STM32-E407.uvproj, settings and files
target Olimex_E407 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Olimex_E407
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, OLIMEX_E407, HSE_VALUE=12000000, ARMCMX, STDSERIAL=3
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\..\..\..\STM32Libraries\armcmx;..\..\..\..\..\STM32Libraries\armcmx\utility
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group User
    ../src/: main.c netconf.c stm32f4x7_eth_bsp.c stm32f4xx_it.c fs.c serial_debug.c httpd_cgi_ssi.c httpd.c
    ../../../../../STM32Libraries/armcmx/utility/: system_stm32f4xx.c
    ../inc/: main.h
  group LwIP
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_i2c.c
    ../../../../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_tim.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group armcmx
    ../../../../../STM32Libraries/armcmx/: armcmx.c armcmx.h delay.c delay.h gpio.c usart.c
    ../../../../../STM32Libraries/armcmx/utility/: stm32_open407vc.c stm32_open407vc.h stm32f4_discovery.h
