# Keil uVision project Project.uvproj, settings and files
target Open407V_C (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Open407VC
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,OPEN407VC,__FPU_PRESENT=1,HSE_VALUE=8000000
  c include: ..\..\..\..\..\STM32Libraries\armcmx\utility;..\..\..\..\..\STM32Libraries\armcmx\utility\board;..\inc;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\MDK-ARM\ARM_CM3;..\..\..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\include;..\..\..\..\..\STM32Libraries\armcmx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group User
    ../src/: main.c netconf.c stm32f4xx_it.c udpecho.c tcpecho.c
    ../../../../../STM32Libraries/armcmx/utility/CMSIS/: system_stm32f4xx.c
    ../inc/: main.h
  group LwIP
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_i2c.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOS_v6.1.0/portable/MDK-ARM/ARM_CM3/: port.c
    ../../../../Utilities/Third_Party/FreeRTOS_v6.1.0/portable/MemMang/: heap_2.c
    ../../../../Utilities/Third_Party/FreeRTOS_v6.1.0/: tasks.c croutine.c list.c queue.c
  group armcmx
    ../../../../../STM32Libraries/armcmx/utility/board/: stm_eval_compat.h stm_eval_compat.c stm32_open407vc.h stm32f4_discovery.h stm32f4x7_eth_bsp.c stm32f4x7_eth_bsp.h
    ../../../../../STM32Libraries/armcmx/: armcmx.c delay.c gpio.c i2c.c usart.c
