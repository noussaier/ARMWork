# Keil uVision project stm32f4-RFID.uvproj, settings and files
target RFID Test (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4-RFID
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER ARMCMX STM32F4_DISCOVERY HSE_VALUE=8000000 STDSERIAL=6
  c include: ..\..\stm32f4-RFID;..\..\STM32Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Libraries\armcmx;..\..\STM32Libraries\armcmx\utility;..\..\STM32Libraries\armcmx\library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group Main
    ./: startup_stm32f4xx.s
    ../: main.cpp
    ../../STM32Libraries/armcmx/utility/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../../STM32Libraries/armcmx/utility/CMSIS/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../../STM32Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armcmx
    ../../STM32Libraries/armcmx/: delay.c gpio.c usart.c armcmx.c Print.cpp Stream.cpp I2CWire.cpp I2CWire.h i2c.c i2c.h
  group armcmxlibrary
    ../../STM32Libraries/armcmx/library/RFID/: ISO14443.h PN532_I2C.cpp PN532_I2C.h
    ../../STM32Libraries/armcmx/library/RTC/: DS1307.cpp DS1307.h
    ../../STM32Libraries/armcmx/library/LCD/: CharacterLCD.h LiquidCrystal.h LiquidCrystal.cpp
